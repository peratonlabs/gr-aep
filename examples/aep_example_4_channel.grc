options:
  parameters:
    generate_options: qt_gui
    id: aep_example
    output_language: python
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: '4'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: nsamps
  id: variable
  parameters:
    value: len(pulse)
  states: {}
- name: num_avg
  id: variable
  parameters:
    value: '16'
  states: {}
- name: pulse
  id: variable
  parameters:
    value: '[0]*10000 + [1]*2960 + [0]*28000'
  states: {}
- name: range_snr
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,1
    label: SNR
    orient: Qt.Horizontal
    start: '-40'
    step: '1'
    stop: '40'
    value: '-10'
  states: {}
- name: range_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Threshold
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.1'
    stop: 5e6
    value: 500e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: snr_lin
  id: variable
  parameters:
    value: math.pow(10.0,range_snr/20.0)
  states: {}
- name: aep_aep_channel_processing_0
  id: aep_aep_channel_processing
  parameters:
    M: M
    num_sc: fft_len
    thresh: range_threshold
  states: {}
- name: aep_aep_metric_0
  id: aep_aep_metric
  parameters:
    M: M
    nmem: '4'
    num_sc: fft_len
    thresh: range_threshold
  states: {}
- name: aep_apply_weights_0
  id: aep_apply_weights
  parameters:
    M: M
    num_avg: num_avg
    num_sc: fft_len
  states: {}
- name: aep_spatial_cov_per_sc_0
  id: aep_spatial_cov_per_sc
  parameters:
    M: M
    fft_size: fft_len
    num_avg: num_avg
  states: {}
- name: aep_uniform_linear_array_0
  id: aep_uniform_linear_array
  parameters:
    angle_degrees: '0'
    num_elements: M
    sep_lambda: '0.25'
  states: {}
- name: aep_uniform_linear_array_0_0
  id: aep_uniform_linear_array
  parameters:
    angle_degrees: '15'
    num_elements: M
    sep_lambda: '0.25'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: analog_fastnoise_source_x_0_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '.001'
    comment: |-
      Add a little bit
      of simulated receiver noise
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '-436881'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: snr_lin
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: M
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
    vlen: M
  states: {}
- name: blocks_complex_to_mag_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_1_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_1_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_1_2
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_1_2_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    num_streams: M
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: fft_len
    offset: '12'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: fft_len
    offset: '12'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_1
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: fft_len
    offset: '12'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_2
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: fft_len
    offset: '12'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_2_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: fft_len
    offset: '12'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_3
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: fft_len
    offset: '12'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_len*M
    type: complex
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: M
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/10
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: pulse
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: fft_len
    type: float
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: M
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.hamming(fft_len)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.hamming(fft_len)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.hamming(fft_len)
  states: {}
- name: fft_vxx_0_0_1
  id: fft_vxx
  parameters:
    fft_size: fft_len
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.hamming(fft_len)
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 1,0,1,1
    label1: ''
    name: AEP Metric
    size: int(nsamps / ( num_avg*fft_len))
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: |-
      Num inputs set to 4 instead of M
      because of grc issue
      If M changes be sure to change
      correspondingly
    gui_hint: 0,0,1,1
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    name: Single Element
    nconnections: '4'
    size: int(nsamps / (fft_len ))
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 2,0,1,1
    label1: ''
    name: Recovered subcarrier
    size: int(nsamps / (fft_len ))
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: source
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: cov
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: source
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: cov
  states: {}

connections:
- [aep_aep_channel_processing_0, '0', aep_apply_weights_0, '0']
- [aep_aep_metric_0, '0', aep_aep_channel_processing_0, '0']
- [aep_aep_metric_0, '0', blocks_vector_to_stream_1, '0']
- [aep_aep_metric_0, '1', aep_aep_channel_processing_0, '1']
- [aep_apply_weights_0, '0', blocks_vector_to_stream_0_0_2, '0']
- [aep_spatial_cov_per_sc_0, '0', virtual_sink_1, '0']
- [aep_uniform_linear_array_0, '0', blocks_add_xx_0, '0']
- [aep_uniform_linear_array_0_0, '0', blocks_add_xx_0, '1']
- [analog_fastnoise_source_x_0, '0', aep_uniform_linear_array_0_0, '0']
- [analog_fastnoise_source_x_0_0, '0', blocks_stream_to_vector_2, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', blocks_add_xx_0_0, '0']
- [blocks_add_xx_0_0, '0', virtual_sink_0, '0']
- [blocks_complex_to_mag_0_1, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_complex_to_mag_0_1_0, '0', qtgui_time_sink_x_1_0, '1']
- [blocks_complex_to_mag_0_1_1, '0', qtgui_time_sink_x_1_0, '2']
- [blocks_complex_to_mag_0_1_2, '0', qtgui_time_sink_x_1_0, '3']
- [blocks_complex_to_mag_0_1_2_0, '0', qtgui_time_sink_x_1_0_0, '0']
- [blocks_interleave_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_keep_m_in_n_0, '0', blocks_complex_to_mag_0_1, '0']
- [blocks_keep_m_in_n_0_0, '0', blocks_complex_to_mag_0_1_0, '0']
- [blocks_keep_m_in_n_0_1, '0', blocks_complex_to_mag_0_1_1, '0']
- [blocks_keep_m_in_n_0_2, '0', blocks_complex_to_mag_0_1_2, '0']
- [blocks_keep_m_in_n_0_2_0, '0', blocks_complex_to_mag_0_1_2_0, '0']
- [blocks_keep_m_in_n_0_3, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', aep_uniform_linear_array_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_stream_to_vector_0_0_1, '0', fft_vxx_0_0_1, '0']
- [blocks_stream_to_vector_1, '0', aep_spatial_cov_per_sc_0, '0']
- [blocks_stream_to_vector_2, '0', blocks_add_xx_0_0, '1']
- [blocks_throttle_0, '0', blocks_multiply_xx_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_interleave_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_keep_m_in_n_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_interleave_0, '1']
- [blocks_vector_to_stream_0_0, '0', blocks_keep_m_in_n_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_interleave_0, '2']
- [blocks_vector_to_stream_0_0_0, '0', blocks_keep_m_in_n_0_1, '0']
- [blocks_vector_to_stream_0_0_1, '0', blocks_interleave_0, '3']
- [blocks_vector_to_stream_0_0_1, '0', blocks_keep_m_in_n_0_2, '0']
- [blocks_vector_to_stream_0_0_2, '0', blocks_keep_m_in_n_0_2_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_keep_m_in_n_0_3, '0']
- [blocks_vector_to_streams_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_streams_0, '1', blocks_stream_to_vector_0_0, '0']
- [blocks_vector_to_streams_0, '2', blocks_stream_to_vector_0_0_0, '0']
- [blocks_vector_to_streams_0, '3', blocks_stream_to_vector_0_0_1, '0']
- [fft_vxx_0, '0', aep_apply_weights_0, '1']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0, '0', aep_apply_weights_0, '2']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [fft_vxx_0_0_0, '0', aep_apply_weights_0, '3']
- [fft_vxx_0_0_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [fft_vxx_0_0_1, '0', aep_apply_weights_0, '4']
- [fft_vxx_0_0_1, '0', blocks_vector_to_stream_0_0_1, '0']
- [virtual_source_0, '0', blocks_vector_to_streams_0, '0']
- [virtual_source_1, '0', aep_aep_metric_0, '0']

metadata:
  file_format: 1
